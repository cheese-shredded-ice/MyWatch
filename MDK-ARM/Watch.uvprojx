# Keil uVision project Watch.uvprojx, settings and files
target Watch (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Watch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../SYSTEM;../User;../User/Tasks/Inc;..\BSP\KEY;..\BSP\AHT21;..\BSP\BL24C02;..\BSP\EM7028;..\BSP\IIC;..\BSP\KT6328;..\BSP\LSM303DLH;..\BSP\MPU6050;..\BSP\OWDG;..\BSP\POWER;..\BSP\SPL06_001;..\BSP\TOUCH;..\User\Func\Inc
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/System
    ../SYSTEM/: delay.c
  group Application/User/User
    ./: user_TasksInit.c
    ../User/Tasks/Src/: user_HardwareInitTask.c user_RunModeTasks.c user_KeyTask.c user_DataSaveTask.c user_MessageSendTask.c user_ChargCheckTask.c user_SensUpdataTask.c
  group Drivers/User/BSP
    ../BSP/KEY/: key.c
    ../BSP/LCD/: lcd.c
    ../BSP/AHT21/: AHT21.c
    ../BSP/BL24C02/: BL24C02.c
    ../BSP/EM7028/: em70x8.c
    ../BSP/IIC/: iic_hal.c
    ../BSP/KT6328/: KT6328.c
    ../BSP/LSM303DLH/: LSM303.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/OWDG/: WDOG.c
    ../BSP/POWER/: power.c
    ../BSP/TOUCH/: CST816.c
    ../BSP/SPL06_001/: SPL06_001.c
  group Application/User/MidFunc
    ../User/Func/Src/: HWDataAccess.c PageManager.c StrCalculate.c
software components: CMSIS:CORE 4.3.0
